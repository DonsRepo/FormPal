# Keil uVision project FormPal.uvproj, settings and files
target FormPalMain (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: FormPal
  AfterMake: fromelf --bin --output .\rvmdk\compdcm_mpu9150.bin .\rvmdk\compdcm_mpu9150.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: ..;..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S FormPal.c
    ../../ek-tm4c123gxl-boostxl-senshub/drivers/: rgb.c
    ../../../../utils/: uartstdio.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../sensorlib/rvmdk/: sensorlib.lib
